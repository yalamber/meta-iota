SUMMARY = "Certbot is a free, open source software tool for automatically using Let’s Encrypt certificates on manually-administrated websites to enable HTTPS."
DESCRIPTION = "Certbot is a free, open source software tool for automatically using Let’s Encrypt certificates on manually-administrated websites to enable HTTPS."
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/Apache-2.0;md5=89aea4e17d99a7cacdbeed46a0096b10"

inherit pypi setuptools3

SRC_URI[md5sum] = "5d3eec57488037947c503d10a8c01c4d"
SRC_URI[sha256sum] = "69b5b7925de0d3b693b00a40bf109d85afb24c7199bf616339d74d59a80d8d96"
