RDEPENDS_${PN} += "${PYTHON_PN}-pycparser"
