SUMMARY = "SHA-3 (Keccak) for Python"
DESCRIPTION = "SHA-3 wrapper (keccak) for Python. The package is a wrapper around the optimized Keccak Code Package."

HOMEPAGE = "https://pypi.org/project/pysha3/"
LICENSE = "CC0-1.0"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/CC0-1.0;md5=0ceb3372c9595f0a8067e55da801e4a1"

SRC_URI[md5sum] = "59cd2db7a9988c1f3f6aee40145e0c96"
SRC_URI[sha256sum] = "fe988e73f2ce6d947220624f04d467faf05f1bbdbc64b0a201296bb3af92739e"

inherit pypi setuptools3
